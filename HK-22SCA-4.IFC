Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: HK-22SCA 4.IFC
Time: 2022-01-05T02:46:32
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 2200外殼螺絲 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 22SADP風鼓右
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 22SADP風鼓左
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 2400TS
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 4英吋3合1側板_Default (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 4英吋3合1垃圾筒_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 4英吋3合1垃圾箱門_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 4英吋3合1外殼固定片
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 4英吋3合1外殼固定片-2
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 4英吋3合1感應器固定片_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 4英吋3合1箱體_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 純碳鋼

# IfcBuildingElementProxy: 4英吋3合1隔板_Default (2)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 4英吋全嵌型內盒_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: BELL CHEM3合1單1台烘手機箱體B_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: BELL CHEM4英吋2合1底座_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: TEST上門_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: TIMER灌膠PC板C
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 灌膠TIMER組
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 鎖頭C628S-1_Default (2)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel
